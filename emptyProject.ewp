# IAR project emptyProject.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\..\..\driverlib\driverlib\MSP430F5xx_6xx; C:\Users\22489\Desktop\msp\430\examples\DriverLib Examples\MSP430F5xx_6xx\00_emptyProject\fun\pwm
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f5529.xcl
  XLINK.XlinkStackSize: 1
  group (top)
    ./: main.c
  group adc
    fun/pwm/: adc.c adc.h
  group driverlib/MSP430F5xx_6xx
    ../../../driverlib/driverlib/MSP430F5xx_6xx/: adc10_a.c adc10_a.h adc12_a.c adc12_a.h aes.c aes.h battbak.c battbak.h comp_b.c comp_b.h crc.c crc.h ctsd16.c ctsd16.h dac12_a.c dac12_a.h dma.c dma.h driverlib.h eusci_a_spi.c eusci_a_spi.h eusci_a_uart.c eusci_a_uart.h eusci_b_i2c.c eusci_b_i2c.h eusci_b_spi.c eusci_b_spi.h flashctl.c flashctl.h gpio.c gpio.h lcd_b.c lcd_b.h ldopwr.c ldopwr.h mpy32.c mpy32.h oa.c oa.h pmap.c pmap.h pmm.c pmm.h ram.c ram.h ref.c ref.h rtc_a.c rtc_a.h rtc_b.c rtc_b.h rtc_c.c rtc_c.h sd24_b.c sd24_b.h sfr.c sfr.h sysctl.c sysctl.h tec.c tec.h timer_a.c timer_a.h timer_b.c timer_b.h timer_d.c timer_d.h tlv.c tlv.h ucs.c ucs.h usci_a_spi.c usci_a_spi.h usci_a_uart.c usci_a_uart.h usci_b_i2c.c usci_b_i2c.h usci_b_spi.c usci_b_spi.h wdt_a.c wdt_a.h
  group driverlib/MSP430F5xx_6xx/inc
    ../../../driverlib/driverlib/MSP430F5xx_6xx/inc/: hw_memmap.h version.h
  group icm
    fun/pwm/: icm.c icm.h
  group icm_data
    fun/pwm/: DF_Filter.c DF_Filter.h DF_IMU.c DF_IMU.h
  group pwm
    fun/pwm/: pwm.c pwm.h
  group spi
    fun/pwm/: spi.c spi.h
  group time
    fun/pwm/: time.c time.h
  group uart
    fun/pwm/: usart.c usart.h
